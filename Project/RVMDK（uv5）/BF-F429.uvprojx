# Keil uVision project BF-F429.uvprojx, settings and files
target LVGL_LCD (6160000::V6.16::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LVGL_LCD +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\lvgl-8.2.0;..\..\lvgl-8.2.0\porting;..\..\lvgl-8.2.0\src;..\..\lvgl-8.2.0\src\hal;..\..\lvgl-8.2.0\src\widgets;..\..\lvgl-8.2.0\src\misc;..\..\lvgl-8.2.0\src\core;..\..\lvgl-8.2.0\src\draw;..\..\lvgl-8.2.0\src\extra;..\..\lvgl-8.2.0\src\extra\libs;..\..\lvgl-8.2.0\src\extra\libs\qrcode;..\..\lvgl-8.2.0\src\extra\themes\default;..\..\lvgl-8.2.0\src\draw\sw;..\..\lvgl-8.2.0\src\hal;..\..\lvgl-8.2.0\src\font
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/led/: bsp_led.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/font/: fonts.c
    ../../User/usart/: bsp_debug_usart.c
  group DOC
    ../../: 必读说明.txt
  group LVGL/src
    ../../lvgl-8.2.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../lvgl-8.2.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../lvgl-8.2.0/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../lvgl-8.2.0/src/extra/layouts/flex/: lv_flex.c
    ../../lvgl-8.2.0/src/extra/layouts/grid/: lv_grid.c
    ../../lvgl-8.2.0/src/extra/libs/bmp/: lv_bmp.c
    ../../lvgl-8.2.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../lvgl-8.2.0/src/extra/libs/freetype/: lv_freetype.c
    ../../lvgl-8.2.0/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../lvgl-8.2.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../lvgl-8.2.0/src/extra/libs/png/: lodepng.c lv_png.c
    ../../lvgl-8.2.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../lvgl-8.2.0/src/extra/libs/rlottie/: lv_rlottie.c
    ../../lvgl-8.2.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../lvgl-8.2.0/src/extra/others/gridnav/: lv_gridnav.c
    ../../lvgl-8.2.0/src/extra/others/monkey/: lv_monkey.c
    ../../lvgl-8.2.0/src/extra/others/snapshot/: lv_snapshot.c
    ../../lvgl-8.2.0/src/extra/themes/basic/: lv_theme_basic.c
    ../../lvgl-8.2.0/src/extra/themes/default/: lv_theme_default.c
    ../../lvgl-8.2.0/src/extra/themes/mono/: lv_theme_mono.c
    ../../lvgl-8.2.0/src/extra/widgets/animimg/: lv_animimg.c
    ../../lvgl-8.2.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../lvgl-8.2.0/src/extra/widgets/chart/: lv_chart.c
    ../../lvgl-8.2.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../lvgl-8.2.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../lvgl-8.2.0/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../lvgl-8.2.0/src/extra/widgets/led/: lv_led.c
    ../../lvgl-8.2.0/src/extra/widgets/list/: lv_list.c
    ../../lvgl-8.2.0/src/extra/widgets/menu/: lv_menu.c
    ../../lvgl-8.2.0/src/extra/widgets/meter/: lv_meter.c
    ../../lvgl-8.2.0/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../lvgl-8.2.0/src/extra/widgets/span/: lv_span.c
    ../../lvgl-8.2.0/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../lvgl-8.2.0/src/extra/widgets/spinner/: lv_spinner.c
    ../../lvgl-8.2.0/src/extra/widgets/tabview/: lv_tabview.c
    ../../lvgl-8.2.0/src/extra/widgets/tileview/: lv_tileview.c
    ../../lvgl-8.2.0/src/extra/widgets/win/: lv_win.c
    ../../lvgl-8.2.0/src/extra/: lv_extra.c
    ../../lvgl-8.2.0/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../lvgl-8.2.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../lvgl-8.2.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../lvgl-8.2.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../lvgl-8.2.0/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../lvgl-8.2.0/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../../lvgl-8.2.0/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../lvgl-8.2.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group LVGL/porting
    ../../lvgl-8.2.0/porting/: lv_port_disp.c lv_port_indev.c
